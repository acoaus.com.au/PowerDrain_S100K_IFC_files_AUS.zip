Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: f9e5a772-afb4-4655-b409-44a608f65106, VersionGUID: 84327f1e-ae92-4a43-98d5-4e3186b5c98f, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 67018.ifc
Time: 2026-05-18T15:20:44+05:30
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.30.11 (ENU) - IFC 24.3.30.11

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcFlowTerminal: PF_ST_PowerDrain_S100K_Channels_AUS_ACO:PowerDrain_S100K_Invert_Depth_150mm to 199mm, PF_ST_PowerDrain_S100K_Channels_AUS_ACO:PowerDrain_S100K_Invert_Depth_150mm to 199mm:378795
In: Level 1
Type - Description: ACO PowerDrain S100K channels; PredefinedType: USERDEFINED; Material: polymer concrete, Iron, Ductile
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: PowerDrain_S100K_Invert_Depth_150mm to 199mm; sets with these values: 2
PowerDrain S100K Schedule - item_description: SK1-18 Sloped channel - (1m); code_supplier_article_C_ANZRS: 67018; net_mass_S_ANZRS: 30.2 kg; URL: https://acodrain.com.au/; productrange: PowerDrain; Manufacturer: ACO; Model: PowerDrain S100K channels; LOD: LOD 300; content_creator_C_ANZRS: ACO Technology Centre, INDIA; OmniClass Title: Rainwater Removal; OmniClass Number: 23.70.50.24; code_specification_URL_C_ANZRS: https://acodrain.com.au/products/powerdrain/#details; info_commercial_C_ANZRS: https://acodrain.com.au/products/powerdrain/#details; info_technical_C_ANZRS: https://acodrain.com.au/products/powerdrain/#details

# IfcFlowTerminal: ZZZ_do not use_PF_ST_PowerDrain_S100K_gratings_ACO:std(nested) (2)
In: Level 1
Type - Description: ACO PowerDrain_S100K_gratings; Material: Iron, Ductile
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
PowerDrain S100K Schedule - item_description: S100K Iron Intercept Heelsafe® Anti-Slip grate (0.5m); code_supplier_article_C_ANZRS: 141299; net_mass_S_ANZRS: 6.8 kg; URL: https://acodrain.com.au/; productrange: PowerDrain; Manufacturer: ACO; Model: PowerDrain_S100K_gratings; LOD: LOD 300; content_creator_C_ANZRS: ACO Technology Centre, INDIA; OmniClass Title: Rainwater Removal; OmniClass Number: 23.70.50.24; code_specification_URL_C_ANZRS: https://acodrain.com.au/products/powerdrain/#details; info_commercial_C_ANZRS: https://acodrain.com.au/products/powerdrain/#details; info_technical_C_ANZRS: https://acodrain.com.au/products/powerdrain/#details
Name (ZZZ_do not use_PF_ST_PowerDrain_S100K_gratings_ACO:std(nested):...)
378799
379365
